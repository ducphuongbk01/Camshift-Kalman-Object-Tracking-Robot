# Keil uVision project PID_POS_Control.uvprojx, settings and files
target PID__POS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PID_POS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\PID_POS_Controller;.\STM32F4xx_StdPeriph_Driver\inc;.\Matlab;.\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: system_stm32f4xx.c system_timetick.c startup_stm32f407xx.s test.c fuzzyController.c
    ./DRIVER/: DRIVER.c
  group STMLib
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Matlab
    ./Matlab/: PID_POS.c PID_POS_data.c
software components: CMSIS:CORE 5.1.1
